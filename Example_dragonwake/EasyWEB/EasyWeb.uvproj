# Keil uVision project EasyWeb.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: EasyWeb
  c flags: Optim=1
  c define: __FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group HTML Source
    ./: webpage.html
  group Configuration Files
    ./: startup_LPC17xx.s system_LPC17xx.c tcpip.h
  group EasyWeb
    ./: tcpip.c EMAC.c easyweb.c Retarget.c
  group Documentation
    ./: Abstract.txt
