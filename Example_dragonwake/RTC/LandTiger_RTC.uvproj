# Keil uVision project LandTiger_RTC.uvproj, settings and files
target LandTiger_RTC (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LandTiger_RTC +hex
  c flags: Optim=1
  c include: .\Source\Drivers\include;.\Source\Drivers\source;.\Source\CMSIS\CM3\DeviceSupport\NXP\LPC17xx\startup;.\Source\CMSIS\CM3\DeviceSupport\NXP\LPC17xx\startup\arm;.\Source\App
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ./Source/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Source/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    ./Source/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group APP
    ./Source/App/: main.c rtc.c uart.c
  group Read
    ./Source/: readme.txt
