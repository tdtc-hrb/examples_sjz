# IAR project uCOS_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\APP; ..\BSP; ..\BSP\OS-v2; ..\BSP\GLCD; ..\ucos-ii\ucos-ii\ports\arm-cortex-m3\generic\iar; ..\ucos-ii\ucos-ii\source; ..\ucos-ii\uc-lib; ..\ucos-ii\uc-cpu; ..\ucos-ii\uc-cpu\arm-cortex-m3\iar; ..\ucos-ii\uC-Probe\Target\Communication\Generic\RS-232\Source; ..\ucos-ii\uC-Probe\Target\Communication\Generic\RS-232\Ports; ..\ucos-ii\uC-Probe\Target\Communication\Generic\Source; ..\ucos-ii\uC-Probe\Target\Demos\Intro\Source; ..\ucos-ii\uC-Probe\Target\Plugins\uCOS-II
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: uCOS_Demo.srec
  ILINK.IlinkOutputFile: uCOS_Demo.out
  ILINK.IlinkIcfFile: ..\BSP\LPC1768_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: app.c app_cfg.h app_hooks.c app_probe.c app_probe.h app_vect.c cpu_cfg.h includes.h os_cfg.h probe_com_cfg.h
  group BSP
    ../BSP/: bsp.c bsp.h bsp_cpu.c bsp_gpio.c bsp_gpio.h bsp_int.c bsp_int.h bsp_pm.c bsp_pm.h bsp_ser.c bsp_ser.h iolpc1766.h iolpc1768.h LPC1768_FLASH.icf LPC1768_FLASH.mac
  group BSP/GLCD
    ../BSP/GLCD/: arm_comm.h board.h drv_glcd.c drv_glcd.h drv_glcd_cnfg.h glcd_ll.c glcd_ll.h Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group BSP/OS-V2
    ../BSP/OS-v2/: bsp_os.c bsp_os.h
  group uC/CPU
    ../uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M3/IAR
    ../uCOS-II/uC-CPU/arm-cortex-m3/IAR/: cpu.h
    ../uCOS-II/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
  group uC/LIB
    ../uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports/ARM-Cortex-M3/IAR
    ../uCOS-II/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-Ⅱ/Ports/ARM-Cortex-M3/Generic/IAR
    ../uCOS-II/uCOS-II/Ports/arm-cortex-m3/Generic/IAR/: os_cpu.h
    ../uCOS-II/uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-Ⅱ/Source
    ../uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/Probe/Target/Communication/Generic/OS/uCOS-II
    ../uCOS-II/uC-Probe/Target/Communication/Generic/OS/uCOS-II/: probe_com_os.c
  group uC/Probe/Target/Communication/Generic/RS-232/OS/uCOS-II
    ../uCOS-II/uC-Probe/Target/Communication/Generic/RS-232/OS/uCOS-II/: probe_rs232_os.c
  group uC/Probe/Target/Communication/Generic/RS-232/Ports
    ../uCOS-II/uC-Probe/Target/Communication/Generic/RS-232/Ports/: probe_rs232c.c probe_rs232c.h
  group uC/Probe/Target/Communication/Generic/RS-232/Source
    ../uCOS-II/uC-Probe/Target/Communication/Generic/RS-232/Source/: probe_rs232.c probe_rs232.h
  group uC/Probe/Target/Communication/Generic/Source
    ../uCOS-II/uC-Probe/Target/Communication/Generic/Source/: probe_com.c probe_com.h
  group uC/Probe/Target/Demo/Intro/Source
    ../uCOS-II/uC-Probe/Target/Demos/Intro/Source/: probe_demo_intro.c probe_demo_intro.h
  group uC/Probe/Target/Demo/Intro/Workspaces
    ../uCOS-II/uC-Probe/Target/Demos/Intro/Workspaces/: Probe-Demo-Intro-Workspace.wsp
  group uC/Probe/Target/Plugins/uCOS-II
    ../uCOS-II/uC-Probe/Target/Plugins/uCOS-II/: os_probe.c os_probe.h
